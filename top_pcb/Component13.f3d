Component13 (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature"